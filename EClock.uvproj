# Keil uVision project EClock.uvproj, settings and files
target EClock (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: 1302.c 1602.c config.c main.c ny3p.c dht.c
